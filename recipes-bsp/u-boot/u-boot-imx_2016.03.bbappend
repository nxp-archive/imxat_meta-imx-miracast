# Copyright (C) 2014-2016 Freescale Semiconductor
# Released under the MIT license (see COPYING.MIT for the terms)

# Add this current directory to the files search path
FILESPATH_prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-Set-HDMI-mode-to-1910x1080M-30.patch \
"
